# Repository rober1982/Taupunktluefter

## KiCad design PCB/KICad-Project/Taupunkt.kicad_pcb

Board: 2 copper layers, 90.0 x 104.0 mm, 19 parts (0 on the bottom side), 12 nets.

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1: 1000uF; CP_Radial_Tantal_D10.5mm_P5.00mm
C2: 10nf; C_Disc_D3.0mm_W2.0mm_P2.50mm
J1: DC PWR; TerminalBlock_bornier-2_P5.08mm
J2: DHT22 inside; TerminalBlock_bornier-3_P5.08mm
J3: DHT22 outside; TerminalBlock_bornier-3_P5.08mm
J4: 20x4 LCD; PinHeader_1x04_P2.54mm_Vertical
J5, J5#2: D1 MINI - RTC; PinHeader_1x08_P2.54mm_Vertical
J6: SD-Card; PinHeader_1x06_P2.54mm_Vertical
J7: Relay Fan2; PinHeader_1x03_P2.54mm_Vertical
J7#2: Relay Fan1; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RST-Switch; PinHeader_1x02_P2.54mm_Vertical
SW2: ModeSwitch; PinHeader_1x03_P2.54mm_Vertical

Connections:
/<NO NET>: A1.27 (+5V), C1.1, C2.1, J1.2, J2.2, J3.2, J4.4, J5.8, J6.5, J7.3, J7#2.3, R1.1, R2.1, R3.2, R4.2, SW2.3 (4)
/CS: A1.13 (D10), J6.1
/D4 - Data inside: A1.7 (D4), J2.3, R1.2
/D5 - Data outside: A1.8 (D5), J3.3, R2.2
/GND: A1.29 (GND), C1.2, C2.2, J1.1, J2.1, J3.1, J4.3, J5.7, J6.6, J7.1, J7#2.1, SW1.2, SW2.1
/MISO: A1.15 (D12), J6.4
/MOSI: A1.14 (D11), J6.3
/RelSwitch: A1.9 (D6), J7.2, J7#2.2, R5.1, R5.2, SW2.2 (3)
/SCK: A1.16 (D13), J6.2
/SCL: A1.24 (A5), J4.1, J5.3, R3.1
/SDA: A1.23 (A4), J4.2, J5.4, R4.1
unnamed: A1.28 (~RESET), SW1.1

## Commit log

2024-06-04 Added PCB
2024-06-04 Added BOM, removed backups, updated files
2024-06-17 Fixed silkscreen (switched inside and outside sensors to match assigned pins in code), slightly moved away the sd card pinheader.
